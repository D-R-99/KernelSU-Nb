## exianb/Kconfig
```kconfig
config PVM_MOD
	tristate "Linux Kernel Module for Safe Memory Access"
	default y
	depends on MODULES
	help
	  Module for Safe Memory Access
```
